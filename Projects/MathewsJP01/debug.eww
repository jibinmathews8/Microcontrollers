<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\STOPWATCH PROJ 6\Stopwatch_Demo\Demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
